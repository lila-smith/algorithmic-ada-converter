v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 70 -160 110 -160 {
lab=D}
N 180 -160 220 -160 {
lab=D_bar}
C {./inverter.sym} 100 -160 0 0 {name=X1}
C {devices/ipin.sym} 70 -160 0 0 {name=p1 lab=D}
C {devices/opin.sym} 220 -160 0 0 {name=p2 lab=D_bar}
